# Keil uVision project onewire_controller.uvprojx, settings and files
target debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: onewire_controller_debug
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\src\app;..\src\board;..\src\ds18b20;..\src\ds1971;..\src\onewire;..\src\USB-FS\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../src/app/: main.c devicetask.c scheduler.c
  group board
    ../src/board/: led.c rtc.c stm32_it.c systick.c timer.c usart.c usb_endp.c usb_desc.c usb_hw_config.c usb_istr.c usb_prop.c usb_pwr.c
  group onewire
    ../src/onewire/: onewire.c
    ../src/ds18b20/: ds18b20.c
    ../src/ds1971/: ds1971.c
  group usb-fs
    ../src/USB-FS/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
target release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: onewire_controller_release
  AfterMake: fromelf --bin "./Objects/onewire_controller_release.axf" --output "./Binary/onewire_controller_release.bin"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:BKP 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:PWR 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:RTC 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
